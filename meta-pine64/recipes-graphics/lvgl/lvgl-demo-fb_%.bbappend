FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0100-lv_linux_drm-only-use-primary-planes.patch;patchdir=lvgl"
